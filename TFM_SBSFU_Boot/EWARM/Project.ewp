# IAR project Project.ewp, settings and files
configuration B-U585I-IOT02A_TFM_SBSFU_Boot (ARM, debug)
  General.OGChipSelectEditMenu: STM32U585AI ST STM32U585AI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: STM32U585xx; USE_HAL_DRIVER; NDEBUG; MCUBOOT_TARGET_CONFIG=<flash_layout.h>; MBEDTLS_CONFIG_FILE=<config-boot.h>; MCUBOOT_DOUBLE_SIGN_VERIF; FLOW_CONTROL; BL2; __INITIAL_SP=ARM_LIB_STACK$$Limit; __STACK_LIMIT=ARM_LIB_STACK$$Base; DEFAULT_UART_BAUDRATE=115200; TFM_DEV_MODE; BOOT_MAX_ALIGN=16
  ICCARM.IExtraOptions: -DNO_TYPEOF
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32U5xx\Include; ..\..\..\..\..\..\Drivers\STM32U5xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\B-U585I-IOT02A; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Drivers\CMSIS\Core\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32U5xx\Include; ..\..\Linker; ..\..\..\..\..\..\Middlewares\Third_Party\mbed-crypto\include; ..\..\..\..\..\..\Middlewares\Third_Party\mbed-crypto\include\psa; ..\..\..\..\..\..\Middlewares\Third_Party\mbed-crypto\library; ..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware; ..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\platform\include; ..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\platform\ext\common; ..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\platform\ext\driver; ..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\bl2\include; ..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\bl2\ext\mcuboot; ..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\bl2\ext\mcuboot\include; ..\..\..\..\..\..\Middlewares\Third_Party\mcuboot\boot\bootutil\include; ..\..\..\..\..\..\Middlewares\Third_Party\mcuboot\boot\bootutil\src; ..\..\..\..\..\..\Middlewares\Third_Party\mcuboot\ext\tinycrypt\lib\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.bin
  prebuild: prebuild.cmd "$PROJ_DIR$" "STM32U585xx"
  postbuild: cmd /C "cmd /C postbuild.bat"
  ILINK.IlinkOutputFile: B-U585I-IOT02A.out
  ILINK.IlinkIcfFile: bl2.icf.i
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Drivers/STM32U5xx_HAL_Driver
    ../../../../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal.c stm32u5xx_hal_cortex.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_exti.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_icache.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_rng.c stm32u5xx_hal_rng_ex.c stm32u5xx_hal_rtc.c stm32u5xx_hal_rtc_ex.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c stm32u5xx_hal_cryp.c stm32u5xx_hal_cryp_ex.c stm32u5xx_hal_pka.c stm32u5xx_hal_hash.c stm32u5xx_hal_hash_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32u5xx.c
  group Middlewares/mcuboot
    ../../../../../../Middlewares/Third_Party/mcuboot/boot/bootutil/src/: bootutil_misc.c caps.c encrypted.c image_ec.c image_ec256.c image_rsa.c image_validate.c loader.c swap_misc.c swap_move.c swap_scratch.c tlv.c fault_injection_hardening.c fault_injection_hardening_delay_rng_mbedtls.c boot_record.c
  group Middlewares/trustedfirmware
    ../../../../../../Middlewares/Third_Party/trustedfirmware/bl2/ext/mcuboot/: bl2_main.c flash_map_extended.c flash_map_legacy.c
    ../../../../../../Middlewares/Third_Party/trustedfirmware/bl2/Src/: flash_map.c security_cnt.c
    ../../../../../../Middlewares/Third_Party/trustedfirmware/platform/ext/common/: uart_stdout.c
    ../../../../../../Middlewares/Third_Party/trustedfirmware/bl2/src/: shared_data.c
  group Middlewares/mbed-crypto
    ../../../../../../Middlewares/Third_Party/mbed-crypto/library/: aes.c asn1parse.c bignum.c cipher.c ctr_drbg.c ecdh.c ecdsa.c ecp.c ecp_curves.c hkdf.c md.c memory_buffer_alloc.c platform.c platform_util.c rsa.c rsa_internal.c sha256.c entropy.c constant_time.c
  group Application/User
    ../Src/: low_level_flash.c low_level_com.c low_level_rng.c low_level_security.c tick.c boot_hal.c low_level_device.c bl2_nv_services.c stm32u5xx_hal_msp.c keys.c keys_map.c mpu_armv8m_drv.c tfm_bl2_shared_data.c aes_alt.c ecdsa_alt.c ecp_alt.c ecp_curves_alt.c rsa_alt.c sha256_alt.c startup_stm32u5xx.c
  group Doc
    ../: README.md
