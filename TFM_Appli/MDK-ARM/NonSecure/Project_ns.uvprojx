# Keil uVision project Project_ns.uvprojx, settings and files
target B-U585I-IOT02A_TFM_Appli_NS (6130001::V6.13.1::.\ARMCLANG)
  device: STM32U585AIIx STMicroelectronics
  pack: Keil.STM32U5xx_DFP.1.0.4
  cpu: CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ
  output: Project
  AfterMake: fromelf #L --bin --output=$L@L.bin
  AfterMake: ..\postbuild.bat .  "1.0.0" "nonsecure"
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32U585xx,USE_HAL_DRIVER,BL2,PS_ENCRYPTION,TFM_PSA_API,TFM_PARTITION_PROTECTED_STORAGE,TFM_PARTITION_INTERNAL_TRUSTED_STORAGE,TFM_PARTITION_CRYPTO,TFM_PARTITION_PLATFORM,TFM_PARTITION_INITIAL_ATTESTATION,TFM_LVL=2,DEFAULT_UART_BAUDRATE=115200,DOMAIN_NS=1
  c include: ../../../../../../../Drivers/CMSIS/Include;../../../../../../../Drivers/CMSIS/Device/ST/STM32U5xx/Include;../../../../../../../Drivers/STM32U5xx_HAL_Driver/Inc;../../../Linker;../../NonSecure/Inc;../../../../../../../Middlewares/Third_Party/trustedfirmware;../../../../../../../Middlewares/Third_Party/trustedfirmware/secure_fw/spm;../../../../../../../Middlewares/Third_Party/trustedfirmware/secure_fw/core;../../../../../../../Middlewares/Third_Party/trustedfirmware/secure_fw/core/include;../../../../../../../Middlewares/Third_Party/trustedfirmware/secure_fw/services;../../../../../../../Middlewares/Third_Party/trustedfirmware/interface/include;../../../../../../../Middlewares/Third_Party/trustedfirmware/platform/include;../../../../../../../Middlewares/Third_Party/trustedfirmware/platform/ext/common;../../../../../../../Middlewares/Third_Party/trustedfirmware/platform/ext/driver;../../../../../../../Middlewares/Third_Party/trustedfirmware/lib/ext/qcbor/inc;../Secure/g/interface/include;../../../../../../../Middlewares/Third_Party/trustedfirmware/interface/include/log;../../Secure_nsclib;../../../../../../../Middlewares/Third_Party/trustedfirmware/test/framework;../../../../../../../Middlewares/Third_Party/trustedfirmware/bl2/include;../../../../../../../Middlewares/Third_Party/trustedfirmware/test/suites/crypto;../../../../../../../Middlewares/Third_Party/trustedfirmware/platform/ext/secure_element/stm
  library: MicroLIB
  scatter file: .\stm32u5xx_ns.sct
  link misc: --predefine=-I../../../Linker
--predefine=-DBL2
--predefine=-DSTM32U585xx
../Secure/veneer.o
--predefine=-DTFM_PSA_API
  group Drivers/STM32U5xx_HAL_Driver
    ../../../../../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal.c stm32u5xx_hal_cortex.c stm32u5xx_hal_crc.c stm32u5xx_hal_crc_ex.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_exti.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../../NonSecure/Src/: system_stm32u5xx.c
  group Middlewares/trustedfirmware/core
    ../../../../../../../Middlewares/Third_Party/trustedfirmware/interface/src/: tfm_crypto_ipc_api.c tfm_firmware_update_ipc_api.c tfm_initial_attestation_ipc_api.c tfm_its_ipc_api.c tfm_platform_ipc_api.c tfm_ps_ipc_api.c tfm_psa_ns_api.c
    ../../../../../../../Middlewares/Third_Party/trustedfirmware/lib/ext/qcbor/src/: UsefulBuf.c
  group Middlewares/trustedfirmware/test
    ../../../../../../../Middlewares/Third_Party/trustedfirmware/test/suites/crypto/: crypto_tests_common.c
    ../../../../../../../Middlewares/Third_Party/trustedfirmware/test/framework/: test_framework.c test_framework_helpers.c
    ../../../../../../../Middlewares/Third_Party/trustedfirmware/log/: tfm_log_raw.c
  group Application/User
    ../../NonSecure/Src/: com.c common.c fw_update_app.c low_level_device.c low_level_flash.c main.c mpu_armv8m_drv.c ns_data.c startup_stm32u5xx.c stm32u5xx_it.c test_protections.c tfm_app.c tfm_app_rot_ipc_api.c tfm_ns_lock.c ymodem.c
software components: CMSIS:CORE 4.3.0
