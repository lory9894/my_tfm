# IAR project Project_ns.ewp, settings and files
configuration B-U585I-IOT02A_TFM_Appli_NS (ARM, debug)
  General.OGChipSelectEditMenu: STM32U585AI ST STM32U585AI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: STM32U585xx; USE_HAL_DRIVER; BL2; TFM_PSA_API; PS_ENCRYPTION; TFM_PARTITION_PROTECTED_STORAGE; TFM_PARTITION_INTERNAL_TRUSTED_STORAGE; TFM_PARTITION_CRYPTO; TFM_PARTITION_PLATFORM; TFM_PARTITION_INITIAL_ATTESTATION; TFM_LVL=2; __INITIAL_SP=ARM_LIB_STACK$$Limit; __STACK_LIMIT=ARM_LIB_STACK$$Base; DEFAULT_UART_BAUDRATE=115200; DOMAIN_NS=1
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32U5xx\Include; ..\..\..\..\..\..\..\Drivers\STM32U5xx_HAL_Driver\Inc; ..\..\..\Linker; ..\..\NonSecure\Inc; ..\..\Secure_nsclib; ..\..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware; ..\..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\interface\include; ..\..\..\..\..\..\..\Middlewares\Third_Party\mbed-crypto\include\mbedtls; ..\..\..\..\..\..\..\Middlewares\Third_Party\mbed-crypto\include\psa; ..\..\..\..\..\..\..\Middlewares\Third_Party\mbed-crypto\include; ..\..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\interface\include\log; ..\..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\lib\ext\qcbor\inc; ..\Secure\g\interface\include; ..\..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\platform\ext\cmsis; ..\..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\platform\ext\driver; ..\..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\test\framework; ..\..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\test\suites\crypto; ..\..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\platform\ext\secure_element\stm
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.bin
  prebuild: prebuild_ns.cmd "$PROJ_DIR$" "STM32U585xx"
  postbuild: cmd /C "cmd /C ..\postbuild.bat "$PROJ_DIR$"  "1.0.0" "nonsecure""
  ILINK.IlinkOutputFile: B-U585I-IOT02A.out
  ILINK.IlinkIcfFile: stm32u585xx_flash_ns.icf.i
  ILINK.IlinkAdditionalLibs: ..\Secure\B-U585I-IOT02A_S\Exe\Project_import_lib.o
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Drivers/STM32U5xx_HAL_Driver
    ../../../../../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal.c stm32u5xx_hal_cortex.c stm32u5xx_hal_crc.c stm32u5xx_hal_crc_ex.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_exti.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../../NonSecure/Src/: system_stm32u5xx.c
  group Middlewares/trustedfirmware/core
    ../../../../../../../Middlewares/Third_Party/trustedfirmware/interface/src/: tfm_crypto_ipc_api.c tfm_initial_attestation_ipc_api.c tfm_its_ipc_api.c tfm_psa_ns_api.c tfm_ps_ipc_api.c tfm_platform_ipc_api.c tfm_firmware_update_ipc_api.c
    ../../../../../../../Middlewares/Third_Party/trustedfirmware/lib/ext/qcbor/src/: UsefulBuf.c
  group Middlewares/trustedfirmware/test
    ../../../../../../../Middlewares/Third_Party/trustedfirmware/test/suites/crypto/: crypto_tests_common.c
    ../../../../../../../Middlewares/Third_Party/trustedfirmware/test/framework/: test_framework.c test_framework_helpers.c
    ../../../../../../../Middlewares/Third_Party/trustedfirmware/log/: tfm_log_raw.c
  group Application/User
    ../../NonSecure/Src/: low_level_flash.c com.c common.c fw_update_app.c stm32u5xx_it.c low_level_device.c main.c ns_data.c test_protections.c tfm_ns_lock.c tfm_app.c ymodem.c mpu_armv8m_drv.c tfm_app_rot_ipc_api.c startup_stm32u5xx.c
  group Doc
    ../../: README.md
